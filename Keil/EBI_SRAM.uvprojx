# Keil uVision project EBI_SRAM.uvprojx, settings and files
target EBI_SRAM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: M463KGCAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.2
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x3FFFF) CLOCK(200000000) CPUTYPE("Cortex-M4") FPU2
  output: EBI_SRAM +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\M463_Library\CMSIS\Include;..\M463_Library\Device\Nuvoton\m460\Include;..\M463_Library\StdDriver\inc;..\..\M463a
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_m460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../M463_Library/Device/Nuvoton/m460/Source/ARM/: startup_m460.s
    ../M463_Library/Device/Nuvoton/m460/Source/: system_m460.c
  group User
    ../: main.c LCD0.c pcv_pid_controller.c
  group Library
    ../M463_Library/StdDriver/src/: retarget.c sys.c clk.c uart.c ebi.c pdma.c gpio.c eadc.c i2c.c timer.c fmc.c epwm.c rtc.c spi.c kpi.c
